# Keil uVision project temperature_gsm_alarm.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: temperature_gsm_alarm +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SIM900A;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MALLOC;..\USER;..\BSP\KEY;..\BSP\LED;..\BSP\USART2;..\BSP;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\BSP\24CXX;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
    ../BSP/: TIM.C communication.c crc16.c
    ../BSP/24CXX/: 24cxx.c
  group HARWARE
    ../SIM900A/: sim900a.c
    ../MALLOC/: malloc.c
    ../BSP/KEY/: key.c
    ../BSP/LED/: led.c
    ../FATFS/exfuns/: mycc936.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group remark
    ../: 调试备注.txt
