# Keil uVision project multi_lock_control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: multi_lock_control +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\BSP\EXTI;..\include;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER;..\USER\delay;..\USER\led;..\USER\IIC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c crc16.c stm32f10x_it.c TIM.C usart.c communication.c 24cxx.c LOCK.C LOCK_STATE.C
    ../USER/delay/: delay.c
    ../USER/led/: led.c
    ../BSP/MB-host/: bsp_MB_host.c
  group LIBRARIES
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group remark
    ../: 调试备注.txt
software components: CMSIS:CORE 5.1.2
